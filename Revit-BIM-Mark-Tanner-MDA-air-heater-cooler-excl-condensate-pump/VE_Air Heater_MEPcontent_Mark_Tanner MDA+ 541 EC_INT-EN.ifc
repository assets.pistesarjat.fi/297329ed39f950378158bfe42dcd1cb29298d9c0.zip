Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement []
Time: 2024-11-05T10:23:34
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 22.0.2.392 - Exporter 22.0.2.392 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 05 10:23:34 2024 * Host: RORZA-RO-LE01 * Database: C:\Users\rorza\AppData\Local\Temp\65dd653d-d926-4247-866d-f9f7193fc75f\f10078e0-15e0-4d31-888a-bbfb4d6c8cf4\ifc * Database version: 5507 * Database creation date: Tue Nov 05 10:23:32 2024 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Tue Nov 05 10:23:32 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 05 10:23:32 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_BuildingStoreyCommon - Reference: Level 1
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1
Other(Type) - Category: Levels; Family Name: Level

# IfcAirTerminal: VE_Air Heater_MEPcontent_Mark_Tanner MDA+ 230V EC_INT-EN:Tanner MDA+ 541 EC, VE_Air Heater_MEPcontent_Mark_Tanner MDA+ 230V EC_INT-EN:Tanner MDA+ 541 EC:18814
In: Level 1
Type - Material: Color RGB 193-193-194, Color RGB 060-060-060, Color RGB 000-000-255
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 794 mm; Drain Diameter: 32 mm; Height: 790 mm; Hydronic Return Diameter: 50.8 mm; Hydronic Supply Diameter: 50.8 mm; Use Nominal Diameter: yes; Width: 1460 mm
Type - Electrical Engineering - Hertz: 50 Hz; Phase: 1; Power: 760 W; Voltage: 230 V
Type - Identity Data - Article Description: Water-supplied air heater/cooler with EC axial fan, excl. condensate pump; Article Type: Tanner MDA+ 541 EC; Base Family Version: 24.12; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Water-supplied air heater/cooler with EC axial fan, excl. condensate pump; EMCS Version: 5.0; ETIM Article Class: EC011395; Family Version: 24.12; GLN: 8719333004471; GTIN: 8720246318890; Manufacturer: Mark; Manufacturer Art. No.: 5060898; Manufacturer URL: https://www.markclimate.com/products/air-heating/water-supplied-air-heating/tanner-mda-water-supplied-air-heater-cooler/; MEPcontent Class: AIR_HEATER; Model: Tanner MDA+ 541 EC; OmniClass Number: 23.75.70.17; OmniClass Title: Water Heated and Cooled Terminal Heating and Cooling Units; Product Line: Mark; Revit Version: 2022; Type Name: Tanner MDA+ 541 EC; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Mechanical - Loads - Max. Air Flow Rate: 2944.44 m3/s; Max. Cooling Power [kW]: 36,49 (7/12-28); Max. Heating Power [kW]: 64,67 (45/40-15); Unit Weight (Kg): 119
Type - Other - Category: Mechanical Equipment; Distance Between Brackets: 1428.2 mm; Family Name: VE_Air Heater_MEPcontent_Mark_Tanner MDA+ 230V EC_INT-EN; Nominal Diameter: 50.8 mm; Outer Diameter: 60.3 mm; Tanner MDA 200: no; Tanner MDA 300: no; Tanner MDA 400: no; Tanner MDA 500: yes
Type - Pset_ManufacturerTypeInformation - Manufacturer: Mark
Pset_AirTerminalBoxTypeCommon - Reference: Tanner MDA+ 541 EC; sets with these values: 3
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 14.8633 m2; Volume: 0.840298 m3
Identity Data - Mark: 1
Mechanical - System Classification: Hydronic Supply,Hydronic Return,Sanitary,Power
Mechanical - Flow - Drain Fixture Units: 0; Hydronic Return Flow: 0 m3/s; Hydronic Supply Flow: 0 m3/s
Model Properties - Pendant Length: 500 mm; Suspension Console: no
Other - Family: VE_Air Heater_MEPcontent_Mark_Tanner MDA+ 230V EC_INT-EN: Tanner MDA+ 541 EC; Family and Type: VE_Air Heater_MEPcontent_Mark_Tanner MDA+ 230V EC_INT-EN: Tanner MDA+ 541 EC; Lenght Pendant Safe: 500 mm; Pendant Safe: 0 mm; Pendant Visible: yes; Suspension Console Offset: 571.5 mm; Type: VE_Air Heater_MEPcontent_Mark_Tanner MDA+ 230V EC_INT-EN: Tanner MDA+ 541 EC; Type Id: VE_Air Heater_MEPcontent_Mark_Tanner MDA+ 230V EC_INT-EN: Tanner MDA+ 541 EC; Vertical Offset: 500 mm
Phasing - Phase Created: New Construction
Visibility - Back Clearance: 600 mm; Bottom Clearance: 200 mm; Front Clearance: 600 mm; Left Clearance: 600 mm; Right Clearance: 100 mm; Service Area: no; Top Clearance: 90 mm

# IfcDistributionPort (4)
Description: Flow
Name | FlowDirection
Port_18814 | SOURCE
2 x Port_18814 | SINK
Port_18814 | SOURCEANDSINK
